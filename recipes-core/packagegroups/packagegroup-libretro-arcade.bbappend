# Fails to build on AM62x, needs more work to be compatible with the platform
LIBRETRO_ARCADE_CORES:remove = " \
	fbneo-libretro \
"
