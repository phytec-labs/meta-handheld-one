SRC_URI:append = " \
	file://bluetooth_controller.scc \
"
